Properties of the parts of a building model (IFC4X1)

# File
Description: ViewDefinition [CoordinationView]
File name: CLP_306.ifc
Time: 2021-11-10T11:38:00
Author: Chuck.Lawson
Organization: Bentley Exton Office
Written by: OpenRoadsDesigner 10.09.00.91
Made in: OpenRoadsDesigner 10.09.00.91
Authorization: Administrator

# IfcAlignment, CLP_306
In: 89230_BK001 -new
Description: CLP_306
